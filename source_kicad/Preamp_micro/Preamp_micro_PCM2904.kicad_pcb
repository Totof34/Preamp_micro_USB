# Repository Totof34/Preamp_micro_USB

File README.md:

Preamp_micro_USB
================

A small project to measure speaker with an electret via USB

If you would have more information about this project please visit 
www.audiyofan.org

A link to the dedicated post 
http://www.audiyofan.org/forum/viewtopic.php?f=57&t=8948

It's just a box connected via USB , you don't need an external sound card to measure your speakers,

You can use REW or ARTA ( free demo version ) or an other program,

The project is based on a capsule electret, a microphone preamp, a loopback
and a second channel with a secured probe to measure the voltage across the speaker ( for ARTA )
connected via a PCM2904 from BB/TI

Under Linux & Mac no drivers is required
Under Windows you can find in the folder "Drivers_windows" all you need to run this box properly

PCB & schema are designed with Kicad

All comments are welcome

Totof

## KiCad design source_kicad/Preamp_micro/Preamp_micro_PCM2904.kicad_pcb

Parts:
C1: 100n
C2, C4: 100µ
C3: 22µ
C5: 1µ
JP1: JUMPER_2_3
K1: MIC_IN
P1: CONN_B+
P2: CONN_OUT
P4, P5, P6, P7: F
R1, R3: 2K2
R2: 10
R4, R5, R6, R7, R8, R15: 10K
R9: 100K
RV1: POT_220K
U1: TL082

Connections:
+5V: P1.1, R2.1
GND: C1.2, C2.2, C3.2, K1.3, P1.2 (PM), P2.2 (PM), P4.1, P5.1, P6.1, P7.1, R8.1, R15.1, U1.4 (V-)
unnamed: R4.1, R8.2, U1.3 (+), U1.5 (+)
unnamed: JP1.3, K1.1, R3.2
unnamed: C5.2, JP1.2
unnamed: JP1.1, K1.2 (PM), R15.2
unnamed: C4.2, P2.1
unnamed: R5.2, R9.1, U1.7
unnamed: C3.1, R1.2, R3.1
unnamed: C5.1, R6.2
unnamed: R5.1, R7.2, U1.2 (-)
unnamed: R6.1, R9.2, U1.6 (-)
unnamed: R7.1, RV1.1
unnamed: C1.1, C2.1, R1.1, R2.2, R4.2, U1.8 (V+)
unnamed: C4.1, RV1.2, RV1.3, U1.1

Notes on the sheet:
Totof Christophe Dedessus Les Moutier License CC by SA www.audiyofan.org 2013

Board: 2 copper layers, 62.6 x 38.8 mm, 25 parts (0 on the bottom side), 15 nets.

## KiCad design source_kicad/PCM2904/PCM2904.kicad_pcb

Parts:
C6, C7, C8, C9, C10, C11, C12, C13, C14: 1µ
C15, C16: 22p
D1, D2: Z_4V1
J1: USB
P8: CONN_GND
P9: CONN_V+
P10: V_OUT
P11: V_IN_L
P12: V_IN_R
P13: V_OUT_L
P14: V_OUT_R
P15: CH2_IN
P16: CH2_OUT
P19, P20, P21, P22: F
R10: 1K5
R11: 2.2
R12, R13: 22
R14: 1M
R16: 910
R17: 8K2
U2: PCM2904
X1: CRYSTAL_12Mhz

Connections:
GND: C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C13.2, C15.2, C16.2, D1.2, J1.4 (GND), J1.5 (Shield_1), J1.6 (Shield_2), P8.1, P19.1, P20.1, P21.1, P22.1, R16.2, U2.4 (DGNDU), U2.11 (AGNDC), U2.18 (AGND_P), U2.22 (AGND_X), U2.24 (TEST0), U2.26 (DGND)
unnamed: C15.1, R14.2, U2.20 (XTO), X1.1
unnamed: C16.1, R14.1, U2.21 (XTI), X1.2
unnamed: C11.2, P10.1, U2.17 (VCC_P1)
unnamed: P11.1, U2.12 (V_IN_L)
unnamed: P12.1, U2.13 (V_IN_R)
unnamed: C12.1, P13.1
unnamed: C12.2, U2.16 (V_OUT_L)
unnamed: C14.1, P14.1
unnamed: C14.2, U2.15 (V_OUT_R)
unnamed: C10.2, U2.19 (VCC_P2)
unnamed: C7.2, U2.23 (VCC_X)
unnamed: P15.1, R17.1
unnamed: D2.2, P16.1, R16.1, R17.2
unnamed: D1.1, D2.1
unnamed: J1.3 (D+), R12.2
unnamed: R13.1, U2.2 (USB_D-)
unnamed: C6.2, R11.2, U2.3 (V_BUS)
unnamed: C8.1, R10.1, U2.8 (SEL0), U2.9 (SEL1), U2.27 (VDD)
unnamed: J1.2 (D-), R13.2
unnamed: C13.1, U2.14 (C_COM)
unnamed: C9.1, U2.10 (VCCC)
unnamed: J1.1 (Vbus), P9.1, R11.1
unnamed: R10.2, R12.1, U2.1 (USB_D+)

Notes on the sheet:
Totof Christophe Dedessus Les Moutier License CC by SA www.audiyofan.org 2013

Board: 2 copper layers, 62.5 x 38.8 mm, 36 parts (1 on the bottom side), 24 nets.

## Commit log

2013-07-25 One lines more about the PCB designed with Kicad
2013-07-25 2 images of the PCB for test
2013-07-25 Create LICENSE
2013-07-25 Update LICENSE
2013-07-25 Adding kicad files and scheme
2013-07-25 Adding image of the box and drawing of the box and electret capsule
2013-07-26 Adding schema
2013-07-26 Adding schema in the README file
2013-07-29 Adding the upgrade of the project, source file & picture
2013-07-30 Adding windows drivers
2013-12-21 Remove old files from the folder "build"
2013-12-21 Add new file for the folder "build"
